** sch_path: sram_4_16_scn4m/pbuf.sch
**.subckt pbuf A Z
*.ipin A
*.opin Z
xbuf_inv1 A zb_int vdd gnd pinv_3
xbuf_inv2 zb_int Z vdd gnd pinv_4
**.ends
.end
